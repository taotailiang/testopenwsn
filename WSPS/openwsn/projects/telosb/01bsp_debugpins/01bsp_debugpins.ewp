# IAR project 01bsp_debugpins.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\telosb\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\boards\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\chips\sht11\; ..\..\..\inc\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h crypto_engine.h debugpins.h eui64.h i2c.h leds.h radio.h radiotimer.h sctimer.h sensors.h spi.h toolchain_defs.h uart.h
  group bsp/boards/telosb
    ../../../bsp/boards/telosb/: adc_sensor.c adc_sensor.h board.c board_info.h cryptoengine.c debugpins.c eui64.c leds.c sctimer.c sensors.c spi.c uart.c
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.c cc2420.h radio.c
  group bsp/chips/sht11
    ../../../bsp/chips/sht11/: sht11.c sht11.h
  group inc
    ../../../inc/: opendefs.h
  group libs
    ../lib_bsp/Debug/Exe/: lib_bsp.r43
  group projects/common/01bsp_debugpins
    ../../common/01bsp_debugpins/: 01bsp_debugpins.c
